# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\system\rtc;..\system\delay;..\HARDWARE\12864;..\HARDWARE\ADC;..\system\TIME2;..\HARDWARE\key;..\HARDWARE\eeprom;..\HARDWARE\Operating;..\HARDWARE\show;..\HARDWARE\CRC8_16;..\system\sys;..\HARDWARE\read_write_flash;..\HARDWARE\rs485;..\HARDWARE\usart1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group system
    ../system/rtc/: RTC.c
    ../system/delay/: delay.c
    ../system/TIME2/: Time_test.c
    ../system/sys/: sys.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/eeprom/: eeprom.c
    ../HARDWARE/12864/: display12864.c
    ../HARDWARE/show/: show.c
    ../HARDWARE/Operating/: operating.c
    ../HARDWARE/CRC8_16/: crc8_16.c
    ../HARDWARE/read_write_flash/: read_write_flash.c
    ../HARDWARE/rs485/: rs485.c
    ../HARDWARE/usart1/: uart1.c
